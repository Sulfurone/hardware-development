# Keil uVision project MSP432.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\Library;..\Basic\Delay;..\Basic;..\Basic\SystemInit;..\Hardware\LED;..\Library;..\Hardware\OLED;..\Basic\RTC;..\Hardware\Button;..\Basic\Usart;..\Basic\PWM;..\Basic\CHE;..\Hardware\KAI;..\Hardware\4x4;..\Hardware\SHUDUO;..\Hardware\BIANMA;..\Hardware\HC-SR04;..\Hardware\MING
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c
  group Basic
    ../Basic/Delay/: delay.c
    ../Basic/SystemInit/: SystemInit.c
    ../Basic/RTC/: rtc.c
    ../Basic/Usart/: usart.c
    ../Basic/PWM/: pwm.c
    ../Hardware/Button/: key.c
    ../Hardware/KAI/: kai.c
  group Hardware
    ../Hardware/LED/: LED.c
    ../Hardware/OLED/: oled.c
    ../Hardware/4x4/: 4x4.c
    ../Hardware/SHUDUO/: shuduo.c
    ../Hardware/BIANMA/: bianma.c
    ../Hardware/MING/: ming.c
    ../Hardware/HC-SR04/: HCSR04.c
  group Library
    ../Library/: msp432p4xx_driverlib.lib timer_a.c timer32.c
software components: CMSIS:CORE 5.1.1, Device:Startup 3.2.2
