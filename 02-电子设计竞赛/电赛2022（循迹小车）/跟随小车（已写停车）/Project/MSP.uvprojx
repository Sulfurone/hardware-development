# Keil uVision project MSP.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: ..\libraries\TiDriver;..\libraries\TiDriver\inc;..\libraries\TiDriver\inc\CMSIS;..\APP;..\libraries\TiDriver\keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c startup_msp432p401r_uvision.s system_msp432p401r.c isr.c
  group Libries
    ../libraries/TiDriver/keil/: msp432p4xx_driverlib.lib
  group App
    ../APP/: uart_calc.c Time_32.c Time_A_PWM.c Time_A_PWM.h SEEKFREE_OLED.c SEEKFREE_OLED.h track.c MOTOR.C
    ../libraries/TiDriver/: HCSR04.c HCSR04.h
    ../libraries/ku/: key.c key.h SystemInit.c SystemInit.h usart.c usart.h
software components: CMSIS:CORE 5.5.0
