# Keil uVision project myprj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: myprj +hex
  c flags: Optim=1
  c include: ../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: Startup.s main.c driverlib.lib key.c OCM12864.c
    ./driverlib/: gpio.c systemInit.c adc.c i2c.c interrupt.c sysctl.c systick.c timer.c uart.c
