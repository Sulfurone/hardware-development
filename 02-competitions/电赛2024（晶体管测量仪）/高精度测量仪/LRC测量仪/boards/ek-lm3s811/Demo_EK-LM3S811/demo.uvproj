# Keil uVision project demo.uvproj, settings and files
target demo (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo
  AfterMake: fromelf --bin --output .\rvmdk\test_demo.bin .\rvmdk\Demo.axf
  c flags: Optim=3 oTime=1
  c include: ..;..\..\..;
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: demo.c Startup.s
    ../../../driverlib/rvmdk/: driverlib.lib
