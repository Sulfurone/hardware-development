# Keil uVision project boot_demo2.uvproj, settings and files
target boot_demo2 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: boot_demo2
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo2.bin .\rvmdk\boot_demo2.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: boot_demo2.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo2.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
